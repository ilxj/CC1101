# Keil uVision project CC1101.uvprojx, settings and files
target CC1101 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030_CC1101
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\STM32F0xx_StdPeriph_Lib_V1.0.0\Libraries\CMSIS\Include;.\STM32F0xx_StdPeriph_Lib_V1.0.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\STM32F0xx_StdPeriph_Lib_V1.0.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\app;.\hal;.\hal_cc1101;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ./app/: main.c stm32f0xx_it.c startup_stm32f0xx.s
    ./STM32F0xx_StdPeriph_Lib_V1.0.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group hal_cc1101
    ./hal_cc1101/: cc1101.c
  group hal
    ./hal/: flash_api.c hal_delay.c hal_exti.c hal_spi.c hal_timer.c hal_uart.c
  group lib
    ./STM32F0xx_StdPeriph_Lib_V1.0.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c
